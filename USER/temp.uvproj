# Keil uVision project temp.uvproj, settings and files
target temp (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: temp +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\CORE;..\FWLIB\inc;..\HARDWARE\USART;..\USER;..\HARDWARE\DMA;..\HARDWARE\delay;..\HARDWARE\sys;..\HARDWARE\SPI;..\HARDWARE\LED;..\USB\USB_APP;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_Device_Library\Class\msc\inc;..\FATFS\src;..\FATFS\exfuns;..\USMART;..\MALLOC;..\GT30L24A3W
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_exti.c
  group HARDWARE
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/sys/: sys.c
    ../HARDWARE/USART/: usart.c uart2.c led_hal.c led.c systick.c timer14.c timers.c
    ../GT30L24A3W/: GD32F103RCT6_GT30L24A3W_KEIL4.lib
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbd_desc.c usbd_usr.c comm.c fifo.c usbd_storage_msd.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_Dev
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group MALLOC
    ../MALLOC/: malloc.c
